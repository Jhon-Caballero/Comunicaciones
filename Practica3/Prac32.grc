options:
  parameters:
    author: Linda y Jhon
    generate_options: qt_gui
    id: Prc3
    output_language: python
    title: Análisis de la estructura de los bloques
  states: {}

blocks:
- name: freq1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20000'
    value: '1200'
  states: {}
- name: freq2
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1'
    stop: '20000'
    value: '2200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '220500'
  states: {}
- name: Jon_Parteenterajon_0
  id: Jon_Parteenterajon
  parameters:
    PARAM1: 'True'
    PARAM2: samp_rate
  states: {}
- name: Jon_Parteenterajon_0_0
  id: Jon_Parteenterajon
  parameters:
    PARAM1: 'False'
    PARAM2: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: freq1
    type: float
  states: {}

connections:
- [Jon_Parteenterajon_0, '0', qtgui_time_sink_x_0, '0']
- [Jon_Parteenterajon_0_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_1, '0', Jon_Parteenterajon_0, '0']
- [analog_sig_source_x_1, '0', Jon_Parteenterajon_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
